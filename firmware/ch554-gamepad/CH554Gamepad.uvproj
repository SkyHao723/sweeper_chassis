# Keil uVision project CH554Gamepad.uvproj, settings and files
target CH554Gamepad (MCS-51)
  device: CH554 WCH
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF)  IROM(0-0x3FFF) CLOCK(24000000)
  output: CH554Gamepad +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Public/: Debug.C
    ./App/: GamepadHost.C
    ./USB/USB_LIB/: USBHOST.C
